Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: INLINE BIM.IFC
Time: 2022-03-28T09:40:52
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy: INLINE Deckel Lamellen BIM
In: Default Storey
Material: AL Mg 1
SolidWorks Custom Properties - Material: AL Mg 1; Gewicht: 183.21

# IfcBuildingElementProxy: INLINE Einputzgehäuse BIM
In: Default Storey
Material: PP
SolidWorks Custom Properties - Material: PP; Gewicht: 129.52

# IfcBuildingElementProxy: INLINE Gehäuse BIM
In: Default Storey
Material: AL Mg 1
SolidWorks Custom Properties - Material: AL Mg 1; Gewicht: 365.04

# IfcBuildingElementProxy: INLINE Scheibe BIM
In: Default Storey
Material: PC

# IfcBuildingElementProxy: Inline Technik
In: Default Storey
Material: Steel
SolidWorks Custom Properties - Version 1: AH3 - AT DS od. BS,LFP 3,2V 3h 1,2W; Version 2: AX3 - AT.DS & BS,LFP 3,2V 3h 1,2W; Version 3: AX8 - AT.DS & BS,LFP 3,2V 8h 1,2W; Version 4: C - zentr. Vers. AC/DC Adressmodul; Version 5: E - für zentrale Versorgung AC/DC; Version 6: FM3 - AT.DS&BS,LFP 3,2V 3h RC250; Version 7: FM8 - AT.DS&BS,LFP 3,2V 8h RC250

# IfcBuildingElementProxy: Leuchtmittel Inline BIM_LED
In: Default Storey
Material: Steel
SolidWorks Custom Properties - Benennung dt.: LED; Version 1: LN - LED 1/2W 4000K BLF100%; Version 2: LW - Power-LED 1-2W BLF 100%

# IfcBuildingElementProxy: Montagefläche_Montagefläche Inline
In: Default Storey
Material: Steel

# IfcElementAssembly: INLINE BIM
In: Default Storey
SolidWorks Custom Properties - Version 1: 1 - pulverbeschichtet weiß RAL 9016; Version 2: 2 - lackiert silbergrau RAL 9006; Version 3: 9 - Pulver schwarz supermatt; Version 4: X - Sonderfarbe zuz. Einmalkosten
PSet_Mass_Property - Mass Measure: 758.828; Area Measure: 457374 m2; Volume Measure: 415375 m3
